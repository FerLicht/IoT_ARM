# Keil uVision project IoT_ARM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.2.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: telnet
  c flags: Optim=4 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c Timer.c ADC.c Thread.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:LED 1.0.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:USART 2.03, Device:RTE_Device 1.0.0, Device:Startup 1.0.0, Device:XMClib:DMA 1.0.0, Device:XMClib:ERU 1.0.0, Device:XMClib:FCE 1.0.0, Device:XMClib:GPIO 1.0.0, Device:XMClib:SCU 1.0.0, Device:XMClib:UART 1.0.0, Device:XMClib:VADC 1.0.0, Network:CORE 6.4.0, Network:Interface:ETH 6.4.0, Network:Socket:BSD 6.4.0, Network:Socket:TCP 6.4.0, Network:Socket:UDP 6.4.0, CMSIS Driver:Ethernet PHY:KSZ8081RNA 6.00, Compiler:I/O:STDOUT 1.0.0
